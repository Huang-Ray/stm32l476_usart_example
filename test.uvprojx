# Keil uVision project test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers;..\A3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c main.h stm32l476xx_it.h stm32l476xx_it.c stm32l476xx.h
  group Drivers
    ./Drivers/: gpio_hori.c gpio_hori.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube LL:Common 1.13.0, Device:STM32Cube LL:RCC 1.13.0, Device:STM32Cube LL:USART 1.13.0, Device:Startup 1.3.1
